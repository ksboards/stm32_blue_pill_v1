# Repository ksboards/stm32_blue_pill_v1

## KiCad design STM32_blue_pill.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15: C; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
J1, J2: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J3: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J5: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9: R; R_0805_2012Metric
SW1: SW_MEC_5G; SW_Push_1P1T_NO_CK_KMR2
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U2: RT9193-33GB; SOT94P279X129-5N
Y1: Crystal; Crystal_SMD_0603-2Pin_6.0x3.5mm
Y2: Crystal; Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering

Connections:
/3V3: C2.1, C7.1, C8.1, C9.1, C12.1, C13.1, C14.1, C15.1, D1.2 (A), D2.2 (A), J1.18, J2.1, J4.1, J4.2, J5.1, R1.2, U1.9, U1.24, U1.36, U1.48, U2.4 (BP), U2.5 (VOUT)
/5V: C10.1, C11.1, J2.3, J3.1 (VBUS), R7.2, U2.1 (VIN), U2.3 (EN)
/BOOT0: R8.1, U1.44
/BOOT1: R9.2, U1.20
/OSCIN: C3.1, R2.1, U1.5, Y1.1
/OSCOUT: C4.2, R2.2, U1.6, Y1.2
/PA0: J1.5, U1.10
/PA1: J1.6, U1.11
/PA2: J1.7, U1.12
/PA3: J1.8, U1.13
/PA4: J1.9, U1.14
/PA5: J1.10, U1.15
/PA6: J1.11, U1.16
/PA7: J1.12, U1.17
/PA8: J2.16, U1.29
/PA9: J2.15, U1.30
/PA10: J2.14, U1.31
/PA15: J2.11, U1.38
/PB0: J1.13, U1.18
/PB1: J1.14, U1.19
/PB3: J2.10, U1.39
/PB4: J2.9, U1.40
/PB5: J2.8, U1.41
/PB6: J2.7, U1.42
/PB7: J2.6, U1.43
/PB8: J2.5, U1.45
/PB9: J2.4, U1.46
/PB10: J1.15, U1.21
/PB11: J1.16, U1.22
/PB12: J2.20, U1.25
/PB13: J2.19, U1.26
/PB14: J2.18, U1.27
/PB15: J2.17, U1.28
/PC13: J1.2, R4.1, U1.2
/PC14: C5.1, J1.3, U1.3, Y2.1
/PC15: C6.2, J1.4, U1.4, Y2.2
/RESET: C1.1, J1.17, R1.1, U1.7; also elsewhere on the board
/SWCLK: J5.3, U1.37
/SWIO: J5.2, U1.34
/USB_CPU_N: J2.13, R6.2, U1.32
/USB_CPU_P: J2.12, R5.2, R7.1, U1.33
/USB_N: J3.2 (D-), R6.1
/USB_P: J3.3 (D+), R5.1
/VBAT: J1.1, U1.1
unnamed: D1.1 (K), R3.2
unnamed: D2.1 (K), R4.2
unnamed: J4.3, R8.2
unnamed: J4.4, R9.1

Notes on the sheet:
MCU_STM32F103CBT
Regulator 5V to 3V3
USB PORT
BOOT PORT
Power and PC13 Indicators
RESET Button
Board I/O pins
DEBUG Interface

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
Board: 4 copper layers, 20.4 x 52.2 mm, 36 parts (22 on the bottom side), 49 nets.

Other parts of the board:
JP1: JP_Jumper_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm

Their connections:
/RESET: JP1.1; also elsewhere on the board

File BOM_STM32_blue_pill.csv:

Id;Référence;Boîtier;Quantité;Désignation;Fournisseur et réf
1;J3;USB_Micro-B_Molex_47346-0001;1;USB_B_Micro;
2;SW1;SW_Push_1P1T_NO_CK_KMR2;1;SW_MEC_5G;
3;Y2;Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering;1;Crystal;
4;Y1;Crystal_SMD_0603-2Pin_6.0x3.5mm;1;Crystal;
5;U2;SOT94P279X129-5N;1;RT9193-33GB;
6;U1;LQFP-48_7x7mm_P0.5mm;1;STM32F103C8Tx;
7;R9,R8,R7,R6,R5,R4,R3,R2,R1;R_0805_2012Metric;9;R;
8;J5;PinHeader_1x04_P2.54mm_Horizontal;1;Conn_01x04;
9;J4;PinHeader_2x03_P2.54mm_Vertical;1;Conn_02x03_Odd_Even;
10;J2,J1;PinHeader_1x20_P2.54mm_Vertical;2;Conn_01x20;
11;D2,D1;LED_0805_2012Metric;2;LED;
12;C15,C14,C13,C12,C11,C10,C9,C8,C7,C6,C5,C4,C3,C2,C1;C_0805_2012Metric;15;C;

## Commit log

2020-11-11 first
2020-11-11 gitignore
2020-11-11 gitignore fix
2020-11-12 new routing on pcb
